Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-12-21T13:13:47
Author: Scarlett Alday, s.aldayaranda@gmail.com
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.3.2.0 - Alternate UI 20.3.2.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Dec 21 13:13:47 2023 * Host: LAPTOP-VOCR0U39 * Database: C:\Users\salda\AppData\Local\Temp\f4a4b753-4ae9-4d53-80cf-da79730d38a0\9e7fd22a-65f0-4d32-8952-bb7b5742d755\ifc * Database version: 5507 * Database creation date: Thu Dec 21 13:13:47 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Dec 21 13:13:47 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Dec 21 13:13:47 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: Deceuninck_Puerta_monorriel_Sliding:Deceuninck_Puerta_Monorriel_Sliding, Deceuninck_Puerta_monorriel_Sliding:Deceuninck_Puerta_Monorriel_Sliding:541797
In: Level 1
Type - Classification: B2030100 Glazed Doors & Entrances (Uniformat); Material: Deceuninck - 1.White/PVC, Aluminium, PVC, Galvanized steel, Glass
Type - Analytical Properties - Analytic Construction: <None>; Define Thermal Properties by: Schematic Type
Type - Construction - Function: Interior; Wall Closure: By host
Type - Dimensions - Construction Height: 1905 mm; Construction Width: 2305 mm; Fixed glass Height: 1806 mm; Fixed glass Width: 2084 mm; Height: 1900 mm; Max. Height: 3000 mm; Max. Width: 3000 mm; Offset: 84 mm; Sliding glass Height: 1827 mm; Sliding glass Width: 2165 mm; Width: 2300 mm
Type - Identity Data - Assembly Code: B2030100; Assembly Description: Glazed Doors & Entrances; Constructive depth: 92mm; C-Section Model: https://skfb.ly/oOHFn; Glass Type: Monolitic, laminated, thermopanel; Glazing capacity: 4 - 28mm; Internacional Certification: ISO 9001-ISO 14001-BS OHSAS 18001 approved by TUV Rheiland; Line: Sliding; Maintenance: https://deceuninck.cl/pdf/mantencion.pdf; Manufacturer: Deceuninck; Model: Door; OmniClass Number: 23.30.10.00; OmniClass Title: Doors; Opening: Sliding; Panels: 1 fixed, 1 sliding; Rail Type: Monorail; Technical Area Chile: info@deceuninckbim.cl; Type Comments: Calculations made based on load of 500 Pa (103km/h); Type Mark: 73; Type Name: Deceuninck_Puerta_Monorriel_Sliding; URL: www.deceuninck.cl; Use: Interior
Type - Materials and Finishes - Available colours: https://deceuninckbim.cl/pdf/fichas/Sliding-monorriel-puerta.pdf; Frame: Deceuninck - 1.White/PVC; Handle: PVC; Rail: Aluminium; Reinforcement: Galvanized steel; Sash: Deceuninck - 1.White/PVC
Type - Model Properties - Acoustic insulation: Rw=34 (-1;-2) dB according to ISO 140-3, ISO 717 **; Air permeability: Class 3 according to EN 12207; Fire Reaction: Class C-s3, d2 according to 13501-1; Water tightness: Class 2A according to EN 12208; Wind load resistance: Class C1/B1according to EN 12210
Type - Other - Category: Doors; Anchura de marco: 75 mm; Family Name: Deceuninck_Puerta_monorriel_Sliding; Proyección marco ext.: 25 mm; Proyección marco int.: 25 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: Deceuninck
Type - Pset_ProductRequirements - Category: Doors
Type - Pset_ProvisionForVoid - Width: 2300 mm; Height: 1900 mm
Material: Glass, Deceuninck - 1.White/PVC
Pset_BuildingElementProxyCommon - Reference: Deceuninck_Puerta_Monorriel_Sliding; sets with these values: 2
Constraints - Level: Level: Level 1; Sill Height: 0 mm
Dimensions - Area: 10.6754 m2; Volume: 0.0961141 m3
Graphics - ON_OFF - Hight Inertia Profile: no
Identity Data - Mark: 50
Other - Family: Deceuninck_Puerta_monorriel_Sliding: Deceuninck_Puerta_Monorriel_Sliding; Family and Type: Deceuninck_Puerta_monorriel_Sliding: Deceuninck_Puerta_Monorriel_Sliding; Head Height: 1900 mm; Host Id: Basic Wall: Generic - 200mm; ON_OFF - Height: no; ON_OFF - Width: no; Type: Deceuninck_Puerta_monorriel_Sliding: Deceuninck_Puerta_Monorriel_Sliding; Type Id: Deceuninck_Puerta_monorriel_Sliding: Deceuninck_Puerta_Monorriel_Sliding
Phasing - Phase Created: New Construction
